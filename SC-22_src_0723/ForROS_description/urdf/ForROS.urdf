Commit message: Chnage Motor Program

File: SC-22_src_0723/ForROS_description/urdf/ForROS.urdf (robot description, URDF)
Before this commit: robot ForROS, 8 links, 7 joints
Links:
- added link map
Joints:
- added joint map_joint: type fixed, parent map, child base_footprint, origin xyz=0 0 0
